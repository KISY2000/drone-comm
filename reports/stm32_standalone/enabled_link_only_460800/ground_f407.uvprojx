# Keil uVision project ground_f407.uvprojx, settings and files
target ground_f407_enabled_link_only_460800_DO_NOT_FLASH (6220000::V6.22::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil::STM32F4xx_DFP@3.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(8000000) ELITTLE
  output: ground_f407_LINK_ONLY_DO_NOT_FLASH
  c flags: Optim=2 uC99=1 v6Lang=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F407xx DC_ROLE_GROUND_F407 DC_BOARD_READY=1 HSE_VALUE=8000000U DC_UART_BAUD=460800u
  c misc: -std=c99
  c include: ..\..\..\..\include;..\..\..\..\platforms\common;..\..\..\..\platforms\stm32\common;..\..\..\..\platforms\stm32\f4;..\..\..\..\deps\stm32f4xx-hal-driver-1.8.5\Inc;..\..\..\..\deps\cmsis-device-f4-2.6.11\Include;..\..\..\..\deps\CMSIS_5-5.9.0\CMSIS\Core\Include
  library: MicroLIB
  scatter file: ..\..\..\..\platforms\stm32\standalone\ground_f407.sct
  link misc: --entry=Reset_Handler --strict
  group startup_and_main
    ../../../../platforms/stm32/standalone/: startup_stm32f407xx.s main.c
    ../../../../deps/cmsis-device-f4-2.6.11/Source/Templates/: system_stm32f4xx.c
  group shared_protocol
    ../../../../src/: dc_protocol.c dc_node.c dc_radio.c
  group manual_board_and_adapter
    ../../../../platforms/common/: dc_byte_ring.c
    ../../../../platforms/stm32/common/: dc_stm32_port.c dc_stm32_app.c main_hooks.c board_peripherals.c
  group vendor_HAL
    ../../../../deps/stm32f4xx-hal-driver-1.8.5/Src/: stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_pwr_ex.c
