# Keil uVision project ground_f103.uvprojx, settings and files
target ground_f103_comm_library (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil::STM32F1xx_DFP@2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: ground_f103_comm (library)
  c flags: Optim=1 uC99=1 v6Lang=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F103xB DC_ROLE_GROUND_F103 DC_STM32_F1
  c misc: -std=c99
  c include: ..\..\..\include;..\..\common;..\common;..\f1;..\..\..\deps\stm32f1xx-hal-driver-1.1.10\Inc;..\..\..\deps\cmsis-device-f1-4.3.5\Include;..\..\..\deps\CMSIS_5-5.9.0\CMSIS\Core\Include
  group shared
    ../../../src/: dc_protocol.c dc_node.c dc_radio.c
  group adapter
    ../../common/: dc_byte_ring.c
    ../common/: dc_stm32_port.c dc_stm32_app.c main_hooks.c board_peripherals.c
  group vendor_HAL
    ../../../deps/stm32f1xx-hal-driver-1.1.10/Src/: stm32f1xx_hal.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c
